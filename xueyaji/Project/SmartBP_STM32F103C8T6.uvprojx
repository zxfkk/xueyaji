# Keil uVision project SmartBP_STM32F103C8T6.uvprojx, settings and files
target SmartBP_STM32F103C8T6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartBP_STM32F103C8T6 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD
  c include: ..\CMSIS;..\Core\Inc;..\Algorithm\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: startup_stm32f10x_md.s system_stm32f10x.c
  group Core
    ../Core/Src/: main.c bsp_sys.c xgzp6847d.c pump_valve.c oled_ssd1306.c
  group Algorithm
    ../Algorithm/Src/: bp_algorithm.c
